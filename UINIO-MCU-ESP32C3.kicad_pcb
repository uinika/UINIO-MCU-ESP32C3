# Repository uinika/UINIO-MCU-ESP32C3

File README.md:

# UINIO-MCU-ESP32C3 核心板

[**UINIO-MCU-ESP32C3**](https://gitee.com/uinika/UINIO-MCU-ESP32C3) 是一款采用 [上海乐鑫科技](https://www.espressif.com.cn) **ESP32-C3** 微控制器的核心板电路设计，该微控制器基于开源的 **RISC-V** 指令集，主频高达 `160MHz`，并且同时具备有 **2.4GHz Wi-Fi** 与 **Bluetooth5** 两种无线接入能力。片上载有 `384KB` 容量的 **ROM**，以及 `400KB` 容量的 **SRAM** 和 `8KB` 容量的 **RTCSRAM**。

## 设计概要

- 完整兼容官方的 [Arduino-ESP32](https://docs.espressif.com/projects/arduino-esp32/en/latest/) 板级支持包；
- 采用 LDO 低压差线性稳压芯片 `ME6211C33M5G` 提供 `3.3V` 电源；
- 预留 **TQFN** 封装的 USB 转 UART 串口芯片 **CH343P** 位置，可以按需进行贴装，不贴装时可以采用右上角的 4 线杜邦针外接串口下载模块；
- 预留有 2.4G 微带天线 **π 型阻抗匹配电路**位置，如果对于信号的收发功率没有严格要求，则可以将位号为 `L1` 的串联电感替换为 `0R` 电阻；
- 预留有 4 个 `2mm` 沉头螺丝开孔，可以用于固定核心板；

## 注意事项

1. 上电之前不能下拉 `IO9/BOOT` 的电平状态，否则 **ESP32-C3** 将会进入**下载模式**；
2. `IO8` 引脚默认进行了上拉，因为如果其为低电平状态，则不能使用串口进行固件下载；
3. `GPIO11` 默认为 SPI 接口 Flash 存储器的 `VDD` 引脚，需要配置之后才能作为 GPIO 使用；
4. 外置的 `W25Q128JVSSIQ` 型 Flash 存储器，其 `VDD` 已经连接至 `3.3V` 电源，使用时无需再行配置，Flash 采用普通的两线制 SPI 总线进行通信；
5. `IO12`、`IO13` 在 **QIO** 模式下被复用为 SPI 信号线 `SPIHD` 和 `SPIWP`，本开发板采用两线制 SPI 的 **DIO** 模式，使用时需要注意将 Flash 配置为 **DIO** 模式；

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 UINIO-MCU-ESP32C3 开源项目提供有如下一系列技术参考资料：

1. [《UINIO-MCU-ESP32 核心板电路设计》](http://www.uinio.com/Project/UINIO-MCU-ESP32/)
2. [《基于 UINIO-MCU-ESP32 的 Arduino 进阶教程》](http://www.uinio.com/Project/Arduino-ESP32/)
3. [《运用 U8G2 与 TFT_eSPI 玩转 UINIO-Monitor 显示屏》](http://www.uinio.com/Project/UINIO-Monitor/)
4. [《BOM 交互式物料清单与 PCB 布线在线预览》](http://uinio.com/archives/BOM/UINIO-MCU-ESP32C3.html)

## KiCad design UINIO-MCU-ESP32C3.kicad_pcb

Parts:
AE1: Antenna_Chip; Texas_SWRA117D_2.4GHz_Right
C1, C5, C10, C16, C19: 1uF; C_0402_1005Metric
C2, C3: 1uF; C_0603_1608Metric
C4: 10uF; C_0402_1005Metric
C6, C8: NC; C_0402_1005Metric
C7, C9, C11, C13, C14, C18: 0.1uF; C_0402_1005Metric
C12: 10nF; C_0402_1005Metric
C15, C17: 15pF; C_0402_1005Metric
D1: LED_Red; LED_0603_1608Metric
D2, D3: LESD5D5.0CT1G; D_SOD-523
D4: 1N4007; Nexperia_CFP3_SOD-123W
F1: 60V 2A; Fuse_1206_3216Metric
J1, J2: Conn_01x22_Pin; PinHeader_1x22_P2.54mm_Vertical
L1: L; L_0402_1005Metric
R1: 2K; R_0603_1608Metric
R2, R4, R5, R6, R7: 10K; R_0402_1005Metric
R3, R8: 5.1K; R_0603_1608Metric
SW1: 复位按键; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.7
SW2: 下载按键; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.7
U1: ME6211C33M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U2: W25Q128JVSSIQ; SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL
U3: ESP32-C3; QFN-32_L5.0-W5.0-P0.50-TL-EP3.7
U4: CH343P; TQFN-16_L3.0-W3.0-P0.50-BL-EP1.7
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
VT1, VT2: S8050; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL
Y1: 40MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/CHIP_EN: C9.1, J1.4, R2.2, SW1.3, SW1.4, U3.7 (CHIP_EN), VT1.3 (C)
/DTR: R5.1, U4.12 (DTRTNOW), VT2.2 (E)
/GPIO0: J1.1, U3.4 (XTAL_32K_P)
/GPIO1: J1.2, U3.5 (XTAL_32K_N)
/GPIO2: J1.3, U3.6 (GPIO2)
/GPIO3: J1.5, U3.8 (GPIO3)
/GPIO4: J1.6, U3.9 (MTMS)
/GPIO5: J1.7, U3.10 (MTDI)
/GPIO6: J1.8, U3.12 (MTCK)
/GPIO7: J1.9, U3.13 (MTDO)
/GPIO8: J1.10, R4.1, U3.14 (GPIO8)
/GPIO9/BOOT: J1.11, R7.1, SW2.3, SW2.4, U3.15 (GPIO9), VT2.3 (C)
/GPIO10: J1.12, U3.16 (GPIO10)
/GPIO18/USB_D-: J2.5, U3.25 (GPIO18)
/GPIO19/USB_D+: J2.4, U3.26 (GPIO19)
/RTS: R6.1, U4.13 (RTS), VT1.2 (E)
/SPICLK: J2.8, U2.6 (CLK), U3.22 (SPICLK)
/SPICS0: J2.9, U2.1 (CS#), U3.21 (SPICS0)
/SPID: J2.7, U2.5 (DI(IO0)), U3.23 (SPID)
/SPIHD/GPIO12: J2.11, U3.19 (SPIHD)
/SPIQ: J2.6, U2.2 (DO(IO1)), U3.24 (SPIQ)
/SPIWP/GPIO13: J2.10, U3.20 (SPIWP)
/U0RXD: J2.3, U3.27 (U0RXD), U4.4 (TXD)
/U0TXD: J2.2, U3.28 (U0TXD), U4.5 (RXD)
/USB_Data+: D3.2 (A2), U4.7 (UD+), USB1.A6 (DP1), USB1.B6 (DP2)
/USB_Data-: D2.2 (A2), U4.8 (UD-), USB1.A7 (DN1), USB1.B7 (DN2)
/VDD_3.3V: C1.1, C4.1, C5.1, C7.1, C10.1, C12.1, C13.2, C14.1, C16.1, C18.1, D4.1 (K), F1.1, J1.13, J1.15, J1.17, J1.19, J1.21, R2.1, R4.2, R7.2, U2.3 (WP#(IO2)), U2.7 (HOLD#/RESET#/(IO3)), U2.8 (VCC), U3.2 (VDD3P3), U3.3 (VDD3P3), U3.11 (VDD3P3_RTC), U3.17 (VDD3P3_CPU), U3.31 (VDDA), U3.32 (VDDA), U4.1 (VIO), U4.6 (V3)
/VDD_5V: C2.2, C11.2, J2.13, J2.15, J2.17, J2.19, J2.21, U1.1 (Vin), U1.3 (CE), U4.3 (VDD5), U4.9 (VBUS), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/VDD_SPI/GPIO11: C19.1, J2.12, U3.18 (VDD_SPI)
GND: AE1.2 (PCB_Trace), C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.1, C14.2, C15.1, C16.2, C17.1, C18.2, C19.2, D1.1 (K), D2.1 (A1), D3.1 (A1), D4.2 (A), J1.14, J1.16, J1.18, J1.20, J1.22, J2.1, J2.14, J2.16, J2.18, J2.20, J2.22, R3.2, R8.2, SW1.1, SW1.2, SW2.1, SW2.2, U1.2 (Vss), U2.4 (GND), U3.33 (EP), U4.2 (GND), U4.17 (EP), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND), Y1.2, Y1.4
unnamed: AE1.1 (FEED), C8.1, L1.2
unnamed: D1.2 (A), R1.1
unnamed: C3.2, F1.2, R1.2, U1.5 (Vout)
unnamed: C6.1, L1.1, U3.1 (LNA_IN)
unnamed: C17.2, U3.29 (XTAL_N), Y1.3
unnamed: C15.2, U3.30 (XTAL_P), Y1.1
unnamed: R3.1, USB1.A5 (CC1)
unnamed: R8.1, USB1.B5 (CC2)
unnamed: R5.2, VT1.1 (B)
unnamed: R6.2, VT2.1 (B)

Notes on the sheet:
ESP32-C3 最小系统
CH343 USB 转 UART 电路
USB Type-C 接口电路
3.3V 线性稳压电路
2.54mm 杜邦针
下载控制电路
Flash 存储器电路

Board: 2 copper layers, 68.6 x 25.4 mm, 50 parts (0 on the bottom side), 40 nets.

Other parts of the board:
HOLE**: Hole-2mm
HOLE**#2, HOLE**#3, HOLE**#4: Hole-2mm

## Commit log

2022-11-08 Initialize project.
2022-11-21 Replace ESP32-C3 Symbol.
2022-12-01 The schematic diagram is drawn.
2022-12-03 Finish PCB Layout.
2022-12-05 Complete wiring.
2022-12-06 Ready for release.
2022-12-07 Release UINIO-MCU-ESP32C3 version 1.0.0.
2022-12-12 Fix bug.
2022-12-14 Release UINIO-MCU-ESP32C3 2.0.0.
2022-12-16 Release UINIO-MCU-ESP32C3 version 2.0.0.
2023-02-02 Prepare version 3.0.0.
2023-02-02 Release UINIO-MCU-ESP32C3 version 3.0.0.
2023-02-03 Release UINIO-MCU-ESP32C3 version 3.1.0.
2023-02-12 Release UINIO-MCU-ESP32C3 version 3.2.0.
2023-02-17 Update PCB layout.
2023-02-27 Update PCB.
2023-03-02 PCB Update.
2023-03-03 Release UINIO-MCU-ESP32C3 version 3.3.0.
2023-03-19 Release UINIO-MCU-ESP32C3 version 3.5.0.
2023-05-11 Re-export the PDF file.
2023-07-05 Release UINIO-MCU-ESP32C3 version 3.5.1.
2023-07-06 Update README.md.
2024-01-10 Release UINIO-MCU-ESP32C3 version 3.5.2.
2024-03-05 Release UINIO-MCU-ESP32C3 version 3.6.0.
2024-03-30 Release UINIO-MCU-ESP32C3 version 3.6.2.
2024-11-20 Replace PCB layout.
2024-11-21 Release UINIO-MCU-ESP32C3 version 5.0.0.
